# IAR project RTOS demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ; STM3210C_EVAL; Net; ..\Libraries\CMSIS\Core\CM3; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32F10x_DSP_Lib\inc; ..\uC-CPU; ..\uC-CPU\ARM-Cortex-M3; ..\uC-LIB; ..\uCOS-II\Ports\arm-cortex-m3; ..\uCOS-II\Source; ..\uC-TCPIP\IF; ..\uC-TCPIP\IF\Ether; ..\uC-TCPIP\NIC\Ether\Atmel_MACB; ..\uC-TCPIP\OS\uCOS-II; ..\uC-TCPIP\Source; ..\Modbus\include; ..\Modbus\port; ..\Modbus\portarch; ..\Modbus\tcp; ..\uC-TCPIP\NIC\Ether\PHY; ..\uC-TCPIP\NIC\Ether\PHY\DM9161AE; ..\BMS; ..\RS485; ..\USART1; ..\UART5; ..\RTC; ..\24CXX; ..\IIC; ..\DIPswitch; ..\USART2; ..\USART3; ..\GPIO
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTOS demo.hex
  ILINK.IlinkOutputFile: RTOS demo.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group 24cxx
    ../24CXX/: 24cxx.c 24cxx.h
  group APP
    ./: app.c stm32_dsp.c stm32f107.c stm32f107.h stm32f10x_it.c
  group BMS
    ../BMS/: bms.c bms.h
  group BSP
    STM3210C_EVAL/: stm32_eval.c stm32_eval.h
  group BSP/Net
    Net/: ethernetif.c ethernetif.h net_bsp.c net_bsp.h
    ../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
    ../Libraries/STM32_ETH_Driver/inc/: stm32_eth.h
  group DIPswitch
    ../DIPswitch/: DIPswitch.c DIPswitch.h
  group DSPLIB
    ../Libraries/STM32F10x_DSP_Lib/src/asm/iar/: cr4_fft_1024_stm32.s cr4_fft_256_stm32.s cr4_fft_64_stm32.s
  group EWARMv5
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group FWLIB/Inc
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h
  group FWLIB/Src
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group GPIO
    ../GPIO/: gpio_control.c gpio_control.h
  group IIC
    ../IIC/: myiic.c myiic.h
  group MODBUS/Port
    ../Modbus/port/: mbconfig.h port.h portevent.c porttcp.c
    ../Modbus/portarch/: portarch.c portarch.h
  group MODBUS/Src
    ../Modbus/: mb.c
    ../Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Modbus/tcp/: mbtcp.c mbtcp.h
  group RS485
    ../RS485/: RS485.c RS485.h
  group RTC
    ../RTC/: RTC_Time.c RTC_Time.h
  group UART5
    ../UART5/: UART5.c UART5.h
  group uC/CPU
    ../uC-CPU/ARM-Cortex-M3/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II/Port
    ../uCOS-II/Ports/arm-cortex-m3/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/TCP-IP/NetIF
    ../uC-TCPIP/IF/: net_if_pkt.c net_if_pkt.h
  group uC/TCP-IP/NetIF/Ether
    ../uC-TCPIP/IF/Ether/: net_if.c net_if.h
  group uC/TCP-IP/NIC
    ../uC-TCPIP/NIC/Ether/Atmel_MACB/: net_nic.c net_nic.h net_nic_def.h
  group uC/TCP-IP/OS/uCOS-II
    ../uC-TCPIP/OS/uCOS-II/: net_os.c net_os.h
  group uC/TCP-IP/Ports/ARM/ARM/IAR
    ../uC-TCPIP/Ports/ARM/IAR/: net_util_a.asm
  group uC/TCP-IP/Source
    ../uC-TCPIP/Source/: net.c net.h net_arp.c net_arp.h net_ascii.c net_ascii.h net_bsd.c net_bsd.h net_buf.c net_buf.h net_cfg_net.h net_conn.c net_conn.h net_ctr.c net_ctr.h net_dbg.c net_dbg.h net_def.h net_err.c net_err.h net_icmp.c net_icmp.h net_ip.c net_ip.h net_sock.c net_sock.h net_stat.c net_stat.h net_tcp.c net_tcp.h net_tmr.c net_tmr.h net_type.h net_udp.c net_udp.h net_util.c net_util.h
  group USART1
    ../USART1/: USART1.c USART1.h
  group USART2
    ../USART2/: USART2.c USART2.h
  group USART3
    ../USART3/: USART3.c USART3.h
